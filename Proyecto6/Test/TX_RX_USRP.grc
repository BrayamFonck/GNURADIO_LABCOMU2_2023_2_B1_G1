options:
  parameters:
    author: Daniela,otto,brayan
    generate_options: qt_gui
    id: TX_RX_USRP
    output_language: python
    title: TX_RX_USRP
  states: {}

blocks:
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: GananciaRX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: GRX_lineal
  id: variable_qtgui_range
  parameters:
    label: GananciaRX
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: GananciaRX_USRP
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: GTX_lineal
  id: variable_qtgui_range
  parameters:
    label: GananciaTX
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.2'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: RB
  id: variable
  parameters:
    value: RS*bps
  states: {}
- name: RS
  id: variable_qtgui_range
  parameters:
    label: Rate sample
    start: '0'
    step: '10000'
    stop: '512000'
    value: '128000'
  states: {}
- name: Sps
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '20'
    value: '8'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M, 2))
  states: {}
- name: escala
  id: variable_qtgui_range
  parameters:
    label: escala
    start: '1'
    step: '1'
    stop: '256'
    value: '128'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc
    start: 50e6
    step: 1e6
    stop: 500e6
    value: 100e6
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '62.832e-3'
  states: {}
- name: mod_ord
  id: variable
  parameters:
    value: '4'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Ruido
    start: '0'
    step: '0.0125'
    stop: '1'
    value: '0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(Sps, Sps, 1.0/float(Sps), beta, Sps*taps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: RS*Sps
  states: {}
- name: samp_sym
  id: variable
  parameters:
    value: bps
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j)
  states: {}
- name: taps
  id: variable
  parameters:
    value: '30'
  states: {}
- name: tr
  id: variable_qtgui_range
  parameters:
    label: trotle
    start: '0'
    step: '100'
    stop: 44100*32
    value: '44100'
  states: {state: disabled}
- name: usrp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_0
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: E3TRadio_diezmador_cc_0
  id: E3TRadio_diezmador_cc
  parameters:
    paso: '8'
  states: {}
- name: GANANCIA_RX
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: complex
  states: {}
- name: GANANCIA_TX
  id: blocks_multiply_const_vxx
  parameters:
    const: GTX_lineal
    type: complex
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Constelation
    label2: Freq
    num_tabs: '3'
  states: {}
- name: Time_audio_entrada
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Menu@0 : 2,0,2,1'
    name: '"Audio inicial"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '0.5'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: escala
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/Sps
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: int((audio_rate)*2)
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/2023_2_comu2_G1/Proyecto5/labachata_manuelturizo.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: mod_ord
    w: loop_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: len(rrc_taps)
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '16'
    init_phase: loop_bw
    loop_bw: loop_bw
    max_dev: '1.2'
    osps: '2'
    sps: samp_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: Sps
    taps: h
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: usrp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: usrp_rate/100
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: usrp_rate/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: usrp_rate/100
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'Menu@1 : 2,0,2,1'
    name: '"Enviada"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'Menu@1 : 2,1,2,1'
    name: '"Recibida"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Menu@2 : 0,0,4,1'
    label1: Transmisor
    label2: Receptor
    name: Mani
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: antes
    label2: despues FIlter
    name: Epic
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Menu@0 : 2,1,2,1'
    label1: Reducida
    label2: Escalada
    name: '"Audio Recibido"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style1: '2'
    type: float
    ylabel: Amplitude RX
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: fff
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: usrp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRX
    samp_rate: usrp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p10
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p0
  states: {state: disabled}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: p0
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: p10
  states: {}

connections:
- [E3TRadio_diezmador_cc_0, '0', analog_agc_xx_0, '0']
- [GANANCIA_RX, '0', digital_constellation_decoder_cb_0, '0']
- [GANANCIA_RX, '0', qtgui_const_sink_x_0_0, '0']
- [GANANCIA_TX, '0', uhd_usrp_sink_0, '0']
- [GANANCIA_TX, '0', virtual_sink_0_0, '0']
- [analog_agc_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_float_to_char_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezmador_cc_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_2, '1']
- [blocks_multiply_const_vxx_2, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_2, '0']
- [blocks_null_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', Time_audio_entrada, '0']
- [blocks_throttle_0, '0', blocks_float_to_char_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', virtual_sink_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_null_sink_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [fir_filter_xxx_0, '0', GANANCIA_RX, '0']
- [interp_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', GANANCIA_TX, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '1']
- [low_pass_filter_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0_1, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_1, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
