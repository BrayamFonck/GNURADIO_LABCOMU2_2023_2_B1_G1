options:
  parameters:
    generate_options: qt_gui
    id: Lab_comu_1
    output_language: python
    title: Primer flujograma
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '5'
    value: '1'
  states: {}
- name: amplitude
  id: variable
  parameters:
    value: '0.1'
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: '1500'
  states: {state: disabled}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '10'
    stop: '1000'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1,2,3,4)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):# only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Promedios_de_tiempos', # will show up in GRC\n            in_sig=[np. float32 ],\n            out_sig=[np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n        self . acum_anterior = 0\n        self . Ntotales = 0\n        self . acum_anterior1 = 0\n        self . acum_anterior2 = 0\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        #output_items[0][:] = input_items[0] * self.example_param\n        x = input_items [0]             # Senial de entrada .\n        y0 = output_items [0]           # Promedio de la senial\n        y1 = output_items [1]           # Media de la senial\n        y2 = output_items [2]           # RMS de la senial\n        y3 = output_items [3]           # Potencia promedio de la senial\n        y4 = output_items [4]           # Desviacion estandar de la senial\n\n        # Calculo del promedio\n        N = len (x)                     #tamaño del numero de datos\n        self . Ntotales = self . Ntotales + N\n        acumulado = self . acum_anterior + np. cumsum (x)\n        self . acum_anterior = acumulado [N -1]\n        y0 [:]= acumulado / self . Ntotales\n        \n        # Calculo de la media cuadratica\n        x2=np. multiply (x,x)\n        acumulado1 = self . acum_anterior1 + np. cumsum (x2)\n        self . acum_anterior1 = acumulado1 [N -1]\n        y1 [:] = acumulado1 / self . Ntotales\n        \n        # Calculo de la RMS\n        y2 [:] = np. sqrt (y1)\n        \n        # Calculo de la potencia promedio\n        y3 [:] = np. multiply (y2 ,y2)\n        \n        # Calculo de la desviacion estandar\n        x3 = np. multiply (x-y0 ,x-y0)\n        acumulado2 = self . acum_anterior2 + np. cumsum (x3)\n        self . acum_anterior2 = acumulado2 [N -1]\n        y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )\n        \n        #return len (x)\n        \n        return len(output_items[0])\n        \n"
    example_param: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"media"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"rms"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"p promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"desviacion"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', epy_block_0, '0']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_noise_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_0, '0']
- [epy_block_0, '2', qtgui_number_sink_0_0_0, '0']
- [epy_block_0, '3', qtgui_number_sink_0_0_0_0, '0']
- [epy_block_0, '4', qtgui_number_sink_0_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
