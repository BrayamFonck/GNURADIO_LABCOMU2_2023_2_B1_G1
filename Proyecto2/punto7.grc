options:
  parameters:
    author: Daniela_Brayan
    copyright: Daniela_Brayan
    generate_options: qt_gui
    id: ModulacionFMRX
    output_language: python
    title: Demodulador_de_emisoras
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '25'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia receptor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 88e6
    step: 1e5
    stop: 108e6
    value: 95.7e6
  states: {}
- name: fcb
  id: variable_qtgui_range
  parameters:
    label: Frecuencia corte filtro
    start: 10e3
    step: 1e2
    stop: 400e3
    value: 100e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/2
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sampleo
    start: 100e3
    step: 50e3
    stop: 8e6
    value: 6.25e6
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate/D
    tau: '75e-6'
  states: {state: disabled}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/D
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):# only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Promedios_de_tiempos', # will show up in GRC\n            in_sig=[np. float32 ],\n            out_sig=[np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n        self . acum_anterior = 0\n        self . Ntotales = 0\n        self . acum_anterior1 = 0\n        self . acum_anterior2 = 0\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        #output_items[0][:] = input_items[0] * self.example_param\n        x = input_items [0]             # Senial de entrada .\n        y0 = output_items [0]           # Promedio de la senial\n        y1 = output_items [1]           # Media de la senial\n        y2 = output_items [2]           # RMS de la senial\n        y3 = output_items [3]           # Potencia promedio de la senial\n        y4 = output_items [4]           # Desviacion estandar de la senial\n\n        # Calculo del promedio\n        N = len (x)                     #tamaño del numero de datos\n        self . Ntotales = self . Ntotales + N\n        acumulado = self . acum_anterior + np. cumsum (x)\n        self . acum_anterior = acumulado [N -1]\n        y0 [:]= acumulado / self . Ntotales\n        \n        # Calculo de la media cuadratica\n        x2=np. multiply (x,x)\n        acumulado1 = self . acum_anterior1 + np. cumsum (x2)\n        self . acum_anterior1 = acumulado1 [N -1]\n        y1 [:] = acumulado1 / self . Ntotales\n        \n        # Calculo de la RMS\n        y2 [:] = np. sqrt (y1)\n        \n        # Calculo de la potencia promedio\n        y3 [:] = np. multiply (y2 ,y2)\n        \n        # Calculo de la desviacion estandar\n        x3 = np. multiply (x-y0 ,x-y0)\n        acumulado2 = self . acum_anterior2 + np. cumsum (x3)\n        self . acum_anterior2 = acumulado2 [N -1]\n        y4 [:] = np. sqrt ( acumulado2 / self . Ntotales )\n        \n        #return len (x)\n        \n        return len(output_items[0])\n        \n"
    example_param: '1.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcb
    decim: D
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e4
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: '0'
    fftsize: '8192'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"media"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"rms"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"p promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"desviacion"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250000'
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', epy_block_0, '0']
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_1, '1']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', epy_block_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '1', qtgui_number_sink_0_0, '0']
- [epy_block_0, '2', qtgui_number_sink_0_0_0, '0']
- [epy_block_0, '3', qtgui_number_sink_0_0_0_0, '0']
- [epy_block_0, '4', qtgui_number_sink_0_0_0_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
