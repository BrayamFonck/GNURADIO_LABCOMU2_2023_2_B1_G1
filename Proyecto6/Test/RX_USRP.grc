options:
  parameters:
    author: Daniela,otto,brayan
    generate_options: qt_gui
    id: TX_RX_USRP
    output_language: python
    title: TX_RX_USRP
  states: {}

blocks:
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: GananciaRX
    start: '0'
    step: '1'
    stop: '30'
    value: '16'
  states: {}
- name: GRX_lineal
  id: variable_qtgui_range
  parameters:
    label: GananciaRX lineal
    start: '0'
    step: '0.5'
    stop: '100'
    value: '52'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: RB
  id: variable
  parameters:
    value: RS*bps
  states: {}
- name: RS
  id: variable_qtgui_range
  parameters:
    label: Rate sample
    start: '0'
    step: '10000'
    stop: '512000'
    value: '128000'
  states: {}
- name: Sps
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '20'
    value: '8'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M, 2))
  states: {}
- name: escala
  id: variable_qtgui_range
  parameters:
    label: escala
    start: '1'
    step: '1'
    stop: '256'
    value: '128'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc
    start: 50e6
    step: 1e6
    stop: 500e6
    value: 100e6
  states: {}
- name: func_probe1
  id: variable_function_probe
  parameters:
    block_id: probe1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: func_probe2
  id: variable_function_probe
  parameters:
    block_id: probe2
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: label1
  id: variable_qtgui_label
  parameters:
    label: Enviado
    type: int
    value: func_probe1
  states: {}
- name: label2
  id: variable_qtgui_label
  parameters:
    label: Recibido
    type: int
    value: func_probe2
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Ruido
    start: '0'
    step: '0.0125'
    stop: '1'
    value: '0'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: fase salida
    start: '-180'
    step: '1'
    stop: '180'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: RS*Sps
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j)
  states: {}
- name: tr
  id: variable_qtgui_range
  parameters:
    label: trotle
    start: '0'
    step: '100'
    stop: 44100*32
    value: '44100'
  states: {state: disabled}
- name: usrp_rate
  id: variable
  parameters:
    value: 1.020408e6
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: volumen
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.2'
  states: {}
- name: E3TRadio_diezmador_cc_0
  id: E3TRadio_diezmador_cc
  parameters:
    paso: '8'
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Constelation
    label2: Freq
    num_tabs: '3'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (1/Sps)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: GRX_lineal
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/escala
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: volumen
    type: float
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phase
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: probe2
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'Menu@1 : 2,1,2,1'
    name: '"Recibida"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: antes
    label2: despues FIlter
    name: Epic
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: red
    label1: recibida
    label2: enviada
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Menu@0 : 2,1,2,1'
    label1: Reducida
    label2: Escalada
    name: '"Audio Recibido"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style1: '2'
    type: float
    ylabel: Amplitude RX
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {state: disabled}

connections:
- [E3TRadio_diezmador_cc_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', E3TRadio_diezmador_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_2, '1']
- [blocks_multiply_const_vxx_2, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_2, '0']
- [blocks_phase_shift_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_phase_shift_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', probe2, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [uhd_usrp_source_1, '0', blocks_phase_shift_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
