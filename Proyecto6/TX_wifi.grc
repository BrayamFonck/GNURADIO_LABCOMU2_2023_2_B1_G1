options:
  parameters:
    author: Daniela,otto,brayan
    generate_options: qt_gui
    id: TX_RX_USRP
    output_language: python
    title: TX_RX_USRP
  states: {}

blocks:
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: GananciaTX_USRP
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: GTX_lineal
  id: variable_qtgui_range
  parameters:
    label: GananciaTX lineal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.2'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: RB
  id: variable
  parameters:
    value: RS*bps
  states: {}
- name: RS
  id: variable_qtgui_range
  parameters:
    label: Rate sample
    start: '0'
    step: '10000'
    stop: '512000'
    value: '128000'
  states: {}
- name: Sps
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '20'
    value: '8'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M, 2))
  states: {}
- name: div
  id: variable_qtgui_range
  parameters:
    label: div
    start: '0'
    step: '2'
    stop: '256'
    value: '1'
  states: {}
- name: escala
  id: variable_qtgui_range
  parameters:
    label: escala
    start: '1'
    step: '1'
    stop: '256'
    value: '128'
  states: {}
- name: fase
  id: variable_qtgui_range
  parameters:
    label: fase
    start: '-180'
    step: '1'
    stop: '180'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: fc
    start: 50e6
    step: 1e6
    stop: 500e6
    value: 144e6
  states: {}
- name: func_probe1
  id: variable_function_probe
  parameters:
    block_id: probe1
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: label1
  id: variable_qtgui_label
  parameters:
    label: Enviado
    type: int
    value: func_probe1
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Ruido
    start: '0'
    step: '0.0125'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: RS*Sps
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j)
  states: {}
- name: tr
  id: variable_qtgui_range
  parameters:
    label: trotle
    start: '0'
    step: '100'
    stop: 44100*32
    value: '44100'
  states: {state: disabled}
- name: usrp_rate
  id: variable_qtgui_range
  parameters:
    label: usrp_rate
    start: '10000'
    step: '1000'
    stop: 2e6
    value: RS*Sps
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: samp_rate/div
  states: {state: disabled}
- name: GANANCIA_TX
  id: blocks_multiply_const_vxx
  parameters:
    const: GTX_lineal
    type: complex
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Constelation
    label2: Freq
    num_tabs: '3'
  states: {}
- name: Time_audio_entrada
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'Menu@0 : 2,0,2,1'
    name: '"Audio inicial"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: escala
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bps
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: fase
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/2023_2_comu2_G1/Proyecto5/labachata_manuelturizo.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccc
  states: {}
- name: probe1
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'Menu@1 : 2,0,2,1'
    name: '"Enviada"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: antes
    label2: despues FIlter
    name: Epic
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_2
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: usrp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p10
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p0
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: p0
  states: {}

connections:
- [GANANCIA_TX, '0', uhd_usrp_sink_2, '0']
- [GANANCIA_TX, '0', virtual_sink_0_0, '0']
- [blocks_float_to_char_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_float_to_char_0, '0', probe1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_phase_shift_0, '0', GANANCIA_TX, '0']
- [blocks_phase_shift_0, '0', virtual_sink_0, '0']
- [blocks_wavfile_source_0, '0', Time_audio_entrada, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_phase_shift_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0_1, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
